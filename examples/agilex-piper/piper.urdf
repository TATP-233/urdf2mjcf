Commit message: v1.0.10: auto mimic

File: examples/agilex-piper/piper.urdf (robot description, URDF)
Before this commit: robot piper_description, 9 links, 8 joints
Joints:
- joint joint8: mimic (none) -> joint=joint7 multiplier=1 offset=0
